# Keil uVision project blinky.uvprojx, settings and files
target BLINKY (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: blinky +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c misc: --thumb -c
  c include: ..\include;..\..\..\..\..\sdk\platform\arch;..\..\..\..\..\sdk\platform\arch\compiler\rvds;..\..\..\..\..\sdk\platform\arch\ll\rvds;..\..\..\..\..\sdk\platform\driver\reg;..\..\..\..\..\sdk\platform\include;..\..\..\..\..\sdk\platform\driver\gpio;..\..\..\..\..\sdk\app_modules\api;..\..\..\..\..\sdk\ble_stack\rwble_hl\rwble_hl;..\..\shared\common_uart;..\..\..\..\..\sdk\platform\driver\uart
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\shared\peripheral_examples.sct
  group boot
    ../../shared/startup/: boot_vectors.s system_ARMCM0.c per_ex_hard_fault.c
  group driver
    ../../../../../sdk/platform/driver/gpio/: gpio.c
    ../../../../../sdk/platform/driver/uart/: uart2.c
  group common_uart
    ../../shared/common_uart/: common_uart.c
  group app
    ../src/: main.c user_periph_setup.c
